# IAR project smart_lock_s.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; doc; drivers; src; startup; utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: smart_lock_s.out
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm33.h mpu_armv7.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group libs
    libs/: iar_lib_power.a
  group source
    source/: Common.h MqttKit.c MqttKit.h smart_lock.c
  group src
    src/: LPC55S69_cm33_core0_flash.icf
  group startup
    startup/: startup_LPC55S69_cm33_core0.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
